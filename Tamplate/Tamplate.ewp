# IAR project Tamplate.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: CORE; STM32F10x_FWLib\inc; SYSTEM\delay; SYSTEM\sys; SYSTEM\usart; UCOSIII\uC-CPU; UCOSIII\uC-CPU\ARM-Cortex-M3\IAR; UCOSIII\uC-LIB; UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\IAR; UCOSIII\uCOS-BSP; UCOSIII\uCOS-CONFIG; UCOSIII\uCOS-III; UCOSIII\uCOS-III\Source; UCOSIII\uCOS-III\Ports; UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\IAR; HARDWARE\LCD; HARDWARE\LED; USER; ; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Tamplate.srec
  ILINK.IlinkOutputFile: Tamplate.out
  ILINK.IlinkIcfFile: USER\STM32_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CORE
    CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    HARDWARE/LCD/: gui.c ILI93xx.c
    HARDWARE/LED/: led.c
  group SYSTEM
    SYSTEM/delay/: delay.c
    SYSTEM/sys/: sys.c
    SYSTEM/usart/: usart.c
  group UCOS_BSP
    UCOSIII/uCOS-BSP/: bsp.c
  group UCOS_CONFIG
    UCOSIII/uCOS-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group UCOS_CORE
    UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOS_CPU
    UCOSIII/uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm cpu_c.c
    UCOSIII/uC-CPU/: cpu_core.c
  group UCOS_LIB
    UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/IAR/: lib_mem_a.asm
  group UCOS_PORT
    UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group USER
    USER/: main.c stm32f10x_it.c system_stm32f10x.c
